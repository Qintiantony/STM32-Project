# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: .\User\led;.\User\beep;.\User\system;.\User\systick;.\User\key;.\User\exti;.\User\time;.\User\PWM;.\User\usart;.\User\LCD;.\User\dht11;.\User\motor;.\User\IRControl;.\User\iic;.\User\sht30;.\User\DAC;.\User\laser;.\User\spi;.\User\adc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./User/: main.c
    ./User/system/: system.c
    ./User/systick/: SysTick.c
    ./User/beep/: beep.c
    ./User/key/: key.c
    ./User/exti/: exti.c
    ./User/time/: time.c
    ./User/led/: led.c
    ./User/PWM/: pwm.c
    ./User/usart/: usart.c
    ./User/LCD/: tftlcd.c
    ./User/dht11/: dht11.c
    ./User/motor/: motor.c
    ./User/IRControl/: hwjs.c
    ./User/iic/: iic.c
    ./User/sht30/: sht30.c
    ./User/DAC/: dac.c
    ./User/laser/: laser.c
    ./User/spi/: spi.c
    ./User/adc/: adc.c
software components: CMSIS:CORE 5.1.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
